Commit message: files

File: objects/_prototype.urdf (robot description, URDF)
Before this commit: robot _name, 1 links, 0 joints
Links:
- link _name: geometry collision mesh filename=_prototype.obj scale=2 2 2; visual mesh filename=_prototype.obj scale=2 2 2
